# Keil uVision project XOA.uvproj, settings and files
target XOA (ARM-ADS)
  device: ADuC7020 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: XOA +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group c files
    ./: XOA v1.2.0 max=600mA.c
  group startup
    ./: startup_RV.s
    d:/Keil/ARM/INC/ADI/: irq_arm.c ADuC7020.def
